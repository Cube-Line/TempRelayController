# Keil uVision project TempRelayController.uvproj, settings and files
target TempRelayController (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: TempRelayController +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: .\Include
  group Startup
    ./Startup/: STARTUP.A51
  group Common
    ./Common/: Common.c Delay.c Key.c Menu.c Segment_Led_Display.c Adc.c Timer.c
  group Main
    ./Main/: Main.C
